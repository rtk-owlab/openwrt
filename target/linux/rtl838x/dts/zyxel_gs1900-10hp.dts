/dts-v1/;


#include <dt-bindings/input/input.h>
#include "rtl838x.dtsi"

/ {
	compatible = "zyxel,gs1900", "realtek,rtl838x-soc";
	model = "Zyxel GS1900-10HP Switch";
/*
	aliases {
		led-boot = &led_status_yellow;
		led-failsafe = &led_status_red;
		led-running = &led_status_blue;
		led-upgrade = &led_status_yellow;
	};
*/
	chosen {
		bootargs = "console=ttyS0,115200 mem=128M";
	};
	
	ethernet0: ethernet@0xbb000000 {
		status = "okay";
		compatible = "realtek,rtl838x-eth";
		reg = <0xbb000000 0x100>;
		#address-cells = <1>;
		#size-cells = <0>;
		local-mac-address = [04 BF 6D 23 A0 B4];
		interrupt-parent = <&cpuintc>;
		interrupts = <32>;
		#interrupt-cells = <1>;
		
	mdio: mdio-bus {
		#address-cells = <1>;
		#size-cells = <0>;

		/* Internal phy */
		phy8: ethernet-phy@8 {
			compatible = "ethernet-phy-ieee802.3-c22";
			phy-is-integrated;
			reg = <8>;
		};
		phy9: ethernet-phy@9 {
			reg = <9>;
			compatible = "ethernet-phy-ieee802.3-c22";
			phy-is-integrated;
		};
		phy10: ethernet-phy@10 {
			reg = <10>;
			compatible = "ethernet-phy-ieee802.3-c22";
			phy-is-integrated:
		};
		phy11: ethernet-phy@11 {
			reg = <11>;
			compatible = "ethernet-phy-ieee802.3-c22";
			phy-is-integrated:
		};
		phy12: ethernet-phy@12 {
			reg = <12>;
			compatible = "ethernet-phy-ieee802.3-c22";
			phy-is-integrated;
		};
		phy13: ethernet-phy@13 {
			reg = <13>;
			compatible = "ethernet-phy-ieee802.3-c22";
			phy-is-integrated;
		};
		phy14: ethernet-phy@14 {
			reg = <14>;
			compatible = "ethernet-phy-ieee802.3-c22";
			phy-is-integrated;
		};
		phy15: ethernet-phy@15 {
			reg = <15>;
			compatible = "ethernet-phy-ieee802.3-c22";
			phy-is-integrated;
		};
		phy24: ethernet-phy@24 {
			compatible = "ethernet-phy-ieee802.3-c22";
			phy-is-integrated;
			sfp;
			reg = <24>;
		};
		phy26: ethernet-phy@26 {
			compatible = "ethernet-phy-ieee802.3-c22";
			phy-is-integrated;
			sfp;
			reg = <26>;
		};
	};
	};

	
	switch0: switch@0 {
		status = "okay";
		compatible = "realtek,rtl838x-switch";
		reg = <0>;
			ports {
		#address-cells = <1>;
		#size-cells = <0>;
	ports {
		#address-cells = <1>;
		#size-cells = <0>;
	
		port@0 {
			reg = <8>;
			label = "lan1";
			phy-handle = <&phy8>;
		};
		port@1 {
			reg = <9>;
			label = "lan2";
			phy-handle = <&phy9>;
		};
		port@2 {
			reg = <10>;
			label = "lan3";
			phy-handle = <&phy10>;
		};
		port@3 {
			reg = <11>;
			label = "lan4";
			phy-handle = <&phy11>;
		};
		port@4 {
			reg = <12>;
			label = "lan5";
			phy-handle = <&phy12>;
		};
		port@5 {
			reg = <13>;
			label = "lan6";
			phy-handle = <&phy13>;
		};
		port@6 {
			reg = <14>;
			label = "lan7";
			phy-handle = <&phy14>;
		};
		port@7 {
			reg = <15>;
			label = "lan8";
			phy-handle = <&phy15>;
		};
	
		port@24 {
			reg = <24>;
			label = "lan9";
			phy-mode = "qsgmii";
			phy-handle = <&phy24>;
		};
		port@26 {
			reg = <26>;
			label = "lan10";
			phy-mode = "qsgmii";
			phy-handle = <&phy26>;
		};
		port@28 {
			ethernet = <&ethernet0>;
			reg = <28>;
			fixed-link {
				speed = <1000>;
				full-duplex;
			};
		};
	};
};

};

&spi0 {

	status = "okay";
	flash@0 {
		compatible = "jedec,spi-nor";
		reg = <0>;
		spi-max-frequency = <10000000>;

		partitions {
			compatible = "fixed-partitions";
			#address-cells = <1>;
			#size-cells = <1>;

			partition@0 {
				label = "u-boot";
				reg = <0x0 0x40000>;
				read-only;
			};
			partition@40000 {
				label = "u-boot-env";
				reg = <0x40000 0x10000>;
				read-only;
			};
			partition@50000 {
				label = "u-boot-env2";
				reg = <0x50000 0x10000>;
				read-only;
			};
			partition@60000 {
				label = "jffs";
				reg = <0x60000 0x100000>;
				read-only;
			};
			partition@160000 {
				label = "jffs2";
				reg = <0x160000 0x100000>;
				read-only;
			};
			partition@b260000 {
				label = "runtime";
				reg = <0x260000 0x6d0000>;
				read-only;
			};
			partition@930000 {
				label = "runtime2";
				reg = <0x930000 0x6d0000>;
			};
		};
	};
};

